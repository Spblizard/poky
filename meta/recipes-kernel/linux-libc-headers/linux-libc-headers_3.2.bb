require linux-libc-headers.inc

PR = "r1"

SRC_URI[md5sum] = "364066fa18767ec0ae5f4e4abcf9dc51"
