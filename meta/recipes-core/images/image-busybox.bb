inherit image

LICENSE = "CLOSED"

IMAGE_INSTALL = "busybox"
